# IAR project 08.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F248 MSP430F248
  General.GStackSize2: 1200
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\APPh
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: ..\APPxcl\lnk430F248-app.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../APPc/: adc.c crc32.c dac.c fsfx.c gps.c gsm.c i2c_bh1750.c i2c_ee.c i2c_htu.c i2c_rtc.c i2c_shr1000.c it.c key.c lcd.c led.c logger.c main.c modbus.c ow.c print.c rfkp.c rtc.c spi_max31855.c spi_max31865.c uart_pc.c wireless.c wk2124.c
